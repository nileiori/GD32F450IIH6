# Keil uVision project GD32F450IIH6.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: GD32F450II GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.0.0
  cpu: IRAM(0x20000000,0x070000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x0200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: GD32F450IIH6 +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=@L.bin !L
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F450,__TARGET_FPU_VFP,ARM_MATH_CM4
  c include: ..\..\GD32F4xx_Firmware_Library\Firmware\CMSIS;..\..\GD32F4xx_Firmware_Library\Firmware\CMSIS\GD\GD32F4xx\Include;..\..\GD32F4xx_Firmware_Library\Firmware\GD32F4xx_standard_peripheral\Include;..\..\mdk;..\..\FreeRTOS;..\..\FreeRTOS\include;..\..\FreeRTOS\portable\RVDS\ARM_CM4F;..\..\src\drivers;..\..\src\api;..\..\src\fpga;..\..\src\Common\inc;..\..\src\fpu_lib
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x70000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group app
    ../: main.c systick.c gd32f4xx_it.c
  group cmsis
    ../../GD32F4xx_Firmware_Library/Firmware/CMSIS/GD/GD32F4xx/Source/: system_gd32f4xx.c
  group startup
    ../../GD32F4xx_Firmware_Library/Firmware/CMSIS/GD/GD32F4xx/Source/ARM/: startup_gd32f450_470.s
  group peripherals
    ../../GD32F4xx_Firmware_Library/Firmware/GD32F4xx_standard_peripheral/Source/: gd32f4xx_can.c gd32f4xx_dbg.c gd32f4xx_dma.c gd32f4xx_enet.c gd32f4xx_exmc.c gd32f4xx_exti.c gd32f4xx_fmc.c gd32f4xx_fwdgt.c gd32f4xx_gpio.c gd32f4xx_misc.c gd32f4xx_pmu.c gd32f4xx_rcu.c gd32f4xx_spi.c gd32f4xx_syscfg.c gd32f4xx_timer.c gd32f4xx_usart.c gd32f4xx_wwdgt.c
  group rtt
    ../../SEGGER_RTT_V766a/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
  group freertos
    ../../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../../FreeRTOS/portable/MemMang/: heap_4.c
    ../../FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
  group Drivers
    ../../src/drivers/: drv_gpio.c drv_spi.c drv_usart.c drv_can.c drv_timer.c
  group api
    ../../src/api/: ch378.c serial.c exmc_sram.c
  group fpga
    ../../src/fpga/: DRamAdapter.c UartAdapter.c FmcAdapter.c
  group common
    ../../src/Common/src/: data_convert.c Time_Unify.c
  group fpu_lib
    ../../src/fpu_lib/: arm_cortexM4lf_math.lib
